Commit message: a1_sim

File: lib/env/a1/marble_cube.urdf (robot description, URDF)
Before this commit: robot cube, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=1 1 1; visual mesh filename=marble_cube.obj scale=.2 .2 .2
